# IAR project wlan_ap.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; DEBUG_GPIO
  ICCARM.CCIncludePath2: ../; ../../../driverlib/; ../../../inc/; ../../common; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ..\dana_release_sdk\libdanavideo; ..\dana_release_sdk\extern; ..\..\..\middleware\framework\pm; ..\..\..\middleware\soc; ..\..\..\middleware\driver\hal; ..\..\..\middleware; ..\..\..\middleware\framework\timer; ..\..\..\middleware\driver; ..\..\..\middleware; ..\..\..\driverlib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wlan_ap.bin
  ILINK.IlinkOutputFile: wlan_ap.out
  ILINK.IlinkIcfFile: wifi_audio_app.icf
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a; ..\dana_release_sdk\libdanavideo\libdana_video.a; ..\..\..\middleware\ewarm\Release\Exe\middleware.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: ak_adc.c ak_key_led.c ak_ocv.c ak_spi.c ak_system_init.c ak_uart.c lp3p0_board.c lp3p0_plat_ops.c main.c pinmux.c
    ../../common/: gpio_if.c i2c_if.c network_common.c network_if.c startup_ewarm.c timer_if.c uart_if.c utils_if.c
