<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\ak_adc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\ak_key_led.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\ak_ocv.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\ak_spi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\ak_system_init.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\ak_uart.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\gpio_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\i2c_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\lp3p0_board.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\lp3p0_plat_ops.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\network_common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\network_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\pinmux.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\startup_ewarm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\timer_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\uart_if.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\common\utils_if.c</name>
  </file>
</project>


