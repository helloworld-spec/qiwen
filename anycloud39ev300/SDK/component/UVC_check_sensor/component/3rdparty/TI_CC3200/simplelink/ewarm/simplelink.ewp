# IAR project simplelink.ewp, settings and files
configuration OS (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: SL_FULL; ewarm; SL_PLATFORM_MULTI_THREADED; DISABLE_DEBUGGER_RECONNECT
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ../; ../source/; ../include/; ../../inc/; ../../driverlib; ../../oslib; ../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simplelink.bin
  ILINK.IlinkOutputFile: simplelink.out
configuration NON_OS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; DISABLE_DEBUGGER_RECONNECT
  ICCARM.CCIncludePath2: ../; ../source/; ../include/; ../../inc/; ../../driverlib; ../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 2
configuration PM_Framework (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../; ../source/; ../include/; ../../inc/; ../../driverlib; ../../oslib; ../../middleware/driver/; ../../middleware/driver/hal/; ../../middleware/framework/pm/; ../../simplelink_extlib/provisioninglib
configuration NON_OS_PM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; NON_OS_PM; DISABLE_DEBUGGER_RECONNECT
  ICCARM.CCIncludePath2: as above
configuration OS_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; SL_PLATFORM_MULTI_THREADED
configuration NON_OS_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
configuration NON_OS_PM_debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; NON_OS_PM
  ICCARM.CCIncludePath2: as above
configuration PM_Framework_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: as above
  group (top)
    ../: cc_pal.c cc_pal_pm.c
    ../source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
